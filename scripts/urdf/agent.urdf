Commit message: added contact sensors, facing memory allocation issues

File: scripts/urdf/agent.urdf (robot description, URDF)
Before this commit: robot agent, 1 links, 0 joints
Links:
- added link dummy
Joints:
- added joint dummy_joint: type planar, parent dummy, child base_link, axis 0 0 1
